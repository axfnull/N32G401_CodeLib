# Keil uVision project Flash_Read_Protection_Porj.uvprojx, settings and files
target N32G401F8S7-1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401F8S7_1 Nationstech
  pack: Nationstech.n32g401f8s7_1_DFP.0.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flash_Read_Protection_Porj
  AfterMake: fromelf --bin --output=.\bin\Flash_Read_Protection_Porj.bin .\Objects\Flash_Read_Protection_Porj.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G401F8S7_1, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g401f8s7_1_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g401f8s7_1.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401f8s7_1.c
  group FWLB
    ../../../../../../firmware/n32g401f8s7_1_std_periph_driver/src/: misc.c n32g401f8s7_1_flash.c n32g401f8s7_1_gpio.c n32g401f8s7_1_rcc.c n32g401f8s7_1_usart.c
  group USER
    ../src/: main.c n32g401f8s7_1_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
