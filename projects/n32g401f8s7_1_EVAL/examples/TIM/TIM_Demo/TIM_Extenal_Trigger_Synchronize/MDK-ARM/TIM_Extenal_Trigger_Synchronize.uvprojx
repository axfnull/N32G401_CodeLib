# Keil uVision project TIM_Extenal_Trigger_Synchronize.uvprojx, settings and files
target N32G401F8S7_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401F8S7_1 Nationstech
  pack: Nationstech.n32g401f8s7_1_DFP.0.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIM_Extenal_Trigger_Synchronize
  AfterMake: fromelf --bin --output=.\bin\TIM_Extenal_Trigger_Synchronize.bin .\Objects\TIM_Extenal_Trigger_Synchronize.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,
  c include: ..\;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32g401f8s7_1_std_periph_driver\inc;..\..\..\TIM_Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g401f8s7_1.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g401f8s7_1.c
  group FWLB
    ../../../../../../../firmware/n32g401f8s7_1_std_periph_driver/src/: misc.c n32g401f8s7_1_dbg.c n32g401f8s7_1_gpio.c n32g401f8s7_1_rcc.c n32g401f8s7_1_tim.c n32g401f8s7_1_usart.c n32g401f8s7_1_dma.c
  group DOC
    ../: readme.txt
  group TIM_Src
    ../../../TIM_Src/: ADTIM_common.c GPTIM_common.c timer_common.c ISR_common.c
  group TIM_External_Trigger_Synchronize
    ../: main.c
