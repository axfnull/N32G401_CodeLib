# Keil uVision project TIMTrigger_AutoInjection.uvprojx, settings and files
target N32G401F8S7_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401F8S7_1 Nationstech
  pack: Nationstech.n32g401f8s7_1_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIMTrigger_AutoInjection +hex
  AfterMake: fromelf --bin --output=.\bin\TIMTrigger_AutoInjection.bin .\Objects\TIMTrigger_AutoInjection.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G401F8S7_1, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\N32G401F8S7_1_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_N32G401F8S7_1.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_N32G401F8S7_1.c
  group FWLB
    ../../../../../../firmware/N32G401F8S7_1_std_periph_driver/src/: misc.c N32G401F8S7_1_adc.c N32G401F8S7_1_gpio.c N32G401F8S7_1_rcc.c N32G401F8S7_1_tim.c N32G401F8S7_1_dma.c
  group USER
    ../src/: main.c N32G401F8S7_1_it.c
  group DOC
    ../: readme.txt
